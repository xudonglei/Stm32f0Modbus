# Keil uVision project test.uvprojx, settings and files
target test (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030x8,USE_HAL_DRIVER
  c misc: --c99
  c include: ..\CORE;..\HALLIB\Inc;..\USER;..\SYSTEM\sys;..\SYSTEM\delay;..\HARDWARE\led;..\HARDWARE\uart;..\HARDWARE\modbus
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm0.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f030x8.s
  group HALLIB
    ../HALLIB/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_dma.c
  group HARDWARE
    ../HARDWARE/led/: led.c
    ../HARDWARE/uart/: uart.c
    ../HARDWARE/modbus/: modbus.c
